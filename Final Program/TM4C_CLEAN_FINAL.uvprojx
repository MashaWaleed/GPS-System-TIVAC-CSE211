# Keil uVision project TM4C_CLEAN_FINAL.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TM4C_CLEAN_FINAL
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c
    ./COTS/MCAL/EEPROM/: EEPROM_Programme.c
    ./COTS/MCAL/GPIO/: GPIO_Proggramm.c
    ./COTS/MCAL/Systick/: STK_program.c
    ./COTS/MCAL/UART/: UART_src.c
    ./COTS/HAL/GPS/: GPS.c
    ./COTS/HAL/LCD/: LCD.c
    ./COTS/HAL/LED/: LED.c
    ./COTS/HAL/SWITCH/: SWITCH.c
    ./COTS/APP/: APP.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
