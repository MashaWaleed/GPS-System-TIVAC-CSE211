# Keil uVision project GPIO_TEST.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C1236H6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO_TEST
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=4
  c include: ..\..\COTS\LIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: GPIO_Proggramm.c GPIO_Private.h GPIO_Interface.h GPIO_Config.h main.c
    ../../COTS/LIB/: STD_TYPES.h BIT_MATH.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
